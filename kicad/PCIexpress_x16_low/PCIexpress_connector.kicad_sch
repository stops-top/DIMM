File: kicad/PCIexpress_x16_low/PCIexpress_connector.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: fix
Parts:
- J1, J2: value (none) -> ~
